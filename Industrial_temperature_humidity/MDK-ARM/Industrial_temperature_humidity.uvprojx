# Keil uVision project Industrial_temperature_humidity.uvprojx, settings and files
target Industrial_temperature_humidity (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08010000,0x000F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Industrial_temperature_humidity +hex
  AfterMake: python ..\Tools\make_ota_pkg.py
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295 --locale=english
  c include: ..\User;..\Drivers;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Middlewares;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\LVGL;..\Middlewares\LVGL\lvgl;..\Middlewares\LVGL\lvgl\src;..\Middlewares\LVGL\lvgl\examples\porting;..\APP\Modbus;..\APP\OTA_wifi;..\APP\UI
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../User/: main.c stm32f4xx_it.c RTOS_TASK.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Middlewares/LVGL/lvgl/: lv_conf.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../Drivers/BSP/LED/: led.c
    ../Drivers/BSP/LCD/: lcd.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/SRAM/: sram.c
    ../Drivers/BSP/TIMER/: btim.c
    ../Drivers/BSP/24CXX/: 24cxx.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/TOUCH/: ctiic.c touch.c gt9xxx.c
    ../Drivers/BSP/NORFLASH/: norflash.c
    ../Drivers/BSP/SPI/: spi.c
    ../Drivers/BSP/BEEP/: beep.c
  group APP/UI
    ../APP/UI/: ui.c cn_font16.c cn_font36.c cn_font48.c
  group APP/Modbus
    ../APP/Modbus/: modbus.c rs485.c
  group APP/OTA_WIFI
    ../APP/OTA_wifi/: ota_24c02.c ota_25q128.c ota_Statemachine.c ota_wifi.c ota_wifi_usart.c
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/lvgl/examples/porting
    ../Middlewares/LVGL/lvgl/examples/porting/: lv_port_disp_template_ClBaW.c lv_port_indev_template_ClBaW.c
  group lvgl/src/core
    ../Middlewares/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group lvgl/src/debugging/monkey
    ../Middlewares/LVGL/lvgl/src/debugging/monkey/: lv_monkey.c
  group lvgl/src/debugging/sysmon
    ../Middlewares/LVGL/lvgl/src/debugging/sysmon/: lv_sysmon.c
  group lvgl/src/display
    ../Middlewares/LVGL/lvgl/src/display/: lv_display.c
  group lvgl/src/draw/convert
    ../Middlewares/LVGL/lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group lvgl/src/draw/dma2d
    ../Middlewares/LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
  group lvgl/src/draw
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group lvgl/src/draw/sw/blend
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group lvgl/src/draw/sw
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group lvgl/src/font/binfont_loader
    ../Middlewares/LVGL/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
  group lvgl/src/font/fmt_txt
    ../Middlewares/LVGL/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
  group lvgl/src/font/font_manager
    ../Middlewares/LVGL/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
  group lvgl/src/font/imgfont
    ../Middlewares/LVGL/lvgl/src/font/imgfont/: lv_imgfont.c
  group lvgl/src/font
    ../Middlewares/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/src/indev
    ../Middlewares/LVGL/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/src/layouts/flex
    ../Middlewares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
  group lvgl/src/layouts/grid
    ../Middlewares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/src/layouts
    ../Middlewares/LVGL/lvgl/src/layouts/: lv_layout.c
  group lvgl/src
    ../Middlewares/LVGL/lvgl/src/: lv_init.c
  group lvgl/src/misc/cache/class
    ../Middlewares/LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group lvgl/src/misc/cache/instance
    ../Middlewares/LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group lvgl/src/misc/cache
    ../Middlewares/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group lvgl/src/misc
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group lvgl/src/osal
    ../Middlewares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group lvgl/src/stdlib/builtin
    ../Middlewares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group lvgl/src/stdlib/clib
    ../Middlewares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/stdlib
    ../Middlewares/LVGL/lvgl/src/stdlib/: lv_mem.c
  group lvgl/src/themes/default
    ../Middlewares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
  group lvgl/src/themes
    ../Middlewares/LVGL/lvgl/src/themes/: lv_theme.c
  group lvgl/src/libs/bin_decoder
    ../Middlewares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group lvgl/src/tick
    ../Middlewares/LVGL/lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets/3dtexture
    ../Middlewares/LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group lvgl/src/widgets/animimage
    ../Middlewares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
  group lvgl/src/widgets/arc
    ../Middlewares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
  group lvgl/src/widgets/arclabel
    ../Middlewares/LVGL/lvgl/src/widgets/arclabel/: lv_arclabel.c
  group lvgl/src/widgets/bar
    ../Middlewares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
  group lvgl/src/widgets/button
    ../Middlewares/LVGL/lvgl/src/widgets/button/: lv_button.c
  group lvgl/src/widgets/buttonmatrix
    ../Middlewares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group lvgl/src/widgets/calendar
    ../Middlewares/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group lvgl/src/widgets/canvas
    ../Middlewares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
  group lvgl/src/widgets/chart
    ../Middlewares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
  group lvgl/src/widgets/checkbox
    ../Middlewares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group lvgl/src/widgets/dropdown
    ../Middlewares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group lvgl/src/widgets/gif
    ../Middlewares/LVGL/lvgl/src/widgets/gif/: lv_gif.c
  group lvgl/src/widgets/image
    ../Middlewares/LVGL/lvgl/src/widgets/image/: lv_image.c
  group lvgl/src/widgets/imagebutton
    ../Middlewares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group lvgl/src/widgets/ime
    ../Middlewares/LVGL/lvgl/src/widgets/ime/: lv_ime_pinyin.c
  group lvgl/src/widgets/keyboard
    ../Middlewares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group lvgl/src/widgets/label
    ../Middlewares/LVGL/lvgl/src/widgets/label/: lv_label.c
  group lvgl/src/widgets/led
    ../Middlewares/LVGL/lvgl/src/widgets/led/: lv_led.c
  group lvgl/src/widgets/line
    ../Middlewares/LVGL/lvgl/src/widgets/line/: lv_line.c
  group lvgl/src/widgets/list
    ../Middlewares/LVGL/lvgl/src/widgets/list/: lv_list.c
  group lvgl/src/widgets/lottie
    ../Middlewares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
  group lvgl/src/widgets/menu
    ../Middlewares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
  group lvgl/src/widgets/msgbox
    ../Middlewares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group lvgl/src/widgets/objx_templ
    ../Middlewares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group lvgl/src/widgets/property
    ../Middlewares/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
  group lvgl/src/widgets/roller
    ../Middlewares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
  group lvgl/src/widgets/scale
    ../Middlewares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
  group lvgl/src/widgets/slider
    ../Middlewares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
  group lvgl/src/widgets/span
    ../Middlewares/LVGL/lvgl/src/widgets/span/: lv_span.c
  group lvgl/src/widgets/spinbox
    ../Middlewares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group lvgl/src/widgets/spinner
    ../Middlewares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
  group lvgl/src/widgets/switch
    ../Middlewares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
  group lvgl/src/widgets/table
    ../Middlewares/LVGL/lvgl/src/widgets/table/: lv_table.c
  group lvgl/src/widgets/tabview
    ../Middlewares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
  group lvgl/src/widgets/textarea
    ../Middlewares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
  group lvgl/src/widgets/tileview
    ../Middlewares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
  group lvgl/src/widgets/win
    ../Middlewares/LVGL/lvgl/src/widgets/win/: lv_win.c
